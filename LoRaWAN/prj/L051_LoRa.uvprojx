# Keil uVision project L051_LoRa.uvprojx, settings and files
target SX126x-SDK (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L051C8Tx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.6.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: L051_sx1278
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L051xx,SX1262DVK1DAS,ACTIVE_REGION=LORAMAC_REGION_CN470,REGION_CN470,USE_TCXO
  c include: ..\src\apps;..\src\boards;..\src\boards\mcu;..\src\boards\mcu\stm32;..\src\boards\mcu\stm32\cmsis;..\src\boards\mcu\stm32\STM32L0xx_HAL_Driver\Inc;..\src\boards\mcu\stm32\STM32L0xx_HAL_Driver\Inc\Legacy;..\src\boards\driver;..\src\boards\driver\cmsis;..\src\mac;..\src\mac\region;..\src\peripherals;..\src\radio;..\src\radio\sx126x;..\src\system;..\src\mac\crypto
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group start
    ../src/boards/driver/cmsis/arm-std/: startup_stm32l051xx.s
  group system
    ../src/system/: adc.c delay.c eeprom.c fifo.c gpio.c timer.c uart.c
  group boards
    ../src/boards/driver/: adc-board.c board.c delay-board.c eeprom-board.c gpio-board.c rtc-board.c uart-board.c spi-board.c sx1262dvk1das-board.c sx1276mb1las-board.c key-board.c oled-board.c
    ../src/boards/driver/cmsis/: system_stm32l0xx.c
  group boards/mcu
    ../src/boards/mcu/: utilities.c
    ../src/boards/mcu/stm32/: sysIrqHandlers.c
    ../src/boards/mcu/stm32/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_firewall.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_gpio.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_spi.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_usart.c
  group mac
    ../src/mac/: LoRaMac.c LoRaMacCrypto.c
    ../src/mac/crypto/: aes.c cmac.c
  group mac/region
    ../src/mac/region/: Region.c RegionCommon.c RegionCN470.c RegionAS923.c RegionAU915.c RegionCN779.c RegionEU433.c RegionEU868.c RegionIN865.c RegionKR920.c RegionUS915.c RegionUS915-Hybrid.c
  group radio-sx126x
    ../src/radio/sx126x/: radio.c sx126x.c
  group radio-sx1276
    ../src/radio/sx1276/: sx1276.c
  group apps
    ../src/apps/: main.c
target SX1276-SDK (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L051C8Tx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.6.0
  cpu: as above
  output: L051_sx1278
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L051xx,HARD_FAULT_HANDLER_ENABLED,SX1276MB1LAS,ACTIVE_REGION=LORAMAC_REGION_CN470,REGION_CN470
  c include: ..\src\apps;..\src\boards\mcu;..\src\boards\mcu\stm32;..\src\boards\mcu\stm32\cmsis;..\src\boards\mcu\stm32\STM32L0xx_HAL_Driver\Inc;..\src\boards\mcu\stm32\STM32L0xx_HAL_Driver\Inc\Legacy;..\src\boards\driver;..\src\boards\driver\cmsis;..\src\mac;..\src\mac\region;..\src\peripherals;..\src\radio;..\src\radio\sx126x;..\src\system;..\src\mac\crypto
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
